# Start cores in EL2 mode
ATFW_OPT_append = ' RCAR_BL33_EXECUTION_EL=1'
